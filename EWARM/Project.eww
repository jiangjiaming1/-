<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTS_DJI_A.ewp</path>
  </project>
  <batchBuild />
</workspace>
